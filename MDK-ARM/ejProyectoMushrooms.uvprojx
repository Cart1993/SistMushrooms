# Keil uVision project ejProyectoMushrooms.uvprojx, settings and files
target ejProyectoMushrooms (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: ejProyectoMushrooms
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE
  c misc: --C99
  c include: ../Inc;   ../Drivers/STM32F4xx_HAL_Driver/Inc;   ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;   ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;   ../Drivers/CMSIS/Include;   ..\Lib\LCD;   ..\Lib\DHT11;   ..\Lib\queue;   ..\Lib\Menu;   ..\Lib\GPRS\inc;   ..\Inc\Drivers;   ..\Src\Drivers;   ..\Lib\GPRS\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal.c stm32f4xx_hal_tim.c stm32f4xx_hal_rcc.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash_ramfunc.c
  group New Group
    ../Lib/DHT11/: DHT11.c
    ../Lib/LCD/: STM_MY_LCD16X2.c
    ../Lib/Menu/: menu.c
    ../Src/Drivers/: controlAmbiental.c fase.c humAmb.c humComp.c humTemp.c light.c soilHumidity.c tempAmb.c tempComp.c ctrlFase.c tempMCU.c funcionInicializacion.c confgGSM.c confgGPRS.c responseSMS.c sendMessage.c getHTTP.c postHTTP.c
    ../Lib/GPRS/src/: AT.c Fibocom.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Application/MDK-ARM
    ./: startup_stm32f401xe.s
software components: CMSIS:CORE 4.1.0
